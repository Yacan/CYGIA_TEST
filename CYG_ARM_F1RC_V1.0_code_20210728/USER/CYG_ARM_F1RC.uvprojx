# Keil uVision project CYG_ARM_F1RC.uvprojx, settings and files
target CYG_ARM_F1RC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CYG_ARM_F1RC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,STDLib
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\PID;..\HARDWARE\ADC;..\HARDWARE\communite;..\HARDWARE\PID;..\USER;..\HARDWARE\SPI;..\HARDWARE\BSP_W5500;..\HARDWARE\Gpio;..\HARDWARE\CMD;..\HARDWARE\IIC;..\HARDWARE\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/adc/: adc.c
    ../HARDWARE/BSP_W5500/: socket.c w5500.c w5500_conf.c
    ../HARDWARE/Gpio/: Gpio.c
    ../HARDWARE/SPI/: SPI_Driver.c
    ../HARDWARE/CMD/: mycmd.c
    ../HARDWARE/IIC/: My_IIC.c cat9555.c
    ../HARDWARE/FLASH/: My_Flash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ./: config.c
    ../SYSTEM/usart/: Usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_dma.c
  group README
    ../: README.TXT
